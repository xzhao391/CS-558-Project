Commit message: MPnet Train

File: assets/ur5/ur5.urdf (robot description, URDF)
Before this commit: robot ur5, 5 links, 4 joints
Links:
- link ee_link: geometry collision box size=0.001 0.001 0.001
